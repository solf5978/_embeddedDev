## ncs_impl/initial/Kconfig/Kconfig.shield
```kconfig
osource "D:/_readilyMGMT/_embeddedDev/_nRF_SDK/v2.5.0/nrf/boards/shields/*/Kconfig.shield"
```
